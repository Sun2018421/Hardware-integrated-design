# Keil uVision project Final.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Final +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Final
  asm include: ..\Final
  group Project
    ./: main.c lcd.h lcd.c
